# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\led;..\..\User\usart;..\..\User\bsp_exti;..\..\User\Key;..\..\User\framework;..\..\User\framework\drivers;..\..\User\framework\modules;..\..\User\app;..\..\User\framework\console;..\..\User\app\game_data;..\..\User\app\game_logic;..\..\User\app\host;..\..\User\app\data_swap;..\..\User\framework\drivers\base_port;..\..\User\app\ui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../../Doc/: readme.txt
  group fk/drivers
    ../../User/framework/drivers/: drv_opt.h drv_timer_tick.c drv_debug_usart.c drv_24c0x.c drv_eye_input.c drv_seg_bus.c drv_io_mos.c readme.txt drv_audio.c drv_ex_inputbus.c drv_ex_led.c
  group fk/drivers/port
    ../../User/framework/drivers/base_port/: drv_24c0x_iic_port.c drv_loop_port.c drv_audio_usart_port.c drv_74hc595_port_for_seg_bus.c drv_seg_graph_lib.c drv_74hc165_port1.c drv_74hc595_port_for_2803.c
  group app/task
    ../../User/app/: task_manager.h task_start.c task_host.c task_listen.c task_player1.c task_player2.c task_player3.c task_ui.c
  group app/game_data
    ../../User/app/game_data/: game_data.h game_data.c game_data_create.c game_data_destroy.c
  group app/game_logic
    ../../User/app/game_data/: game_data_config.c
    ../../User/app/game_logic/: game_logic.h game_logic_deal.c
  group app/task_host
    ../../User/app/host/: host.h host_master_thread.c exled_coroutine.c seg_coroitine.c doll_move_coroutine.c gun_sta_coroutine.c keyboard_coroutine.c
  group app/game_logic/cc
    ../../User/app/game_logic/cc/: game_logic_cc_coin.c game_logic_cc_transmitter.c game_logic_cc_gun.c game_logic_cc_ball_recycle_score.c game_logic_cc_doll_score.c game_logic_cc_gift_out.c game_logic_cc_keyled.c
  group app/ui
    ../../User/app/ui/: ui_manager.c ui_page_idle.c ui_page_selt_args_page.c ui_page_set_args_page.c
